# IAR project emulStorageKeyboard.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 256
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../; ../USB_config; ../driverlib/MSP430F5xx_6xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -P(CONST)MYDRIVE=0x10000-0x243FF; -gstorageVol
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: hal.c hal.h main.c
    ./: low_level_init.c
  group driverlib/MSP430F5xx_6xx
    ../driverlib/MSP430F5xx_6xx/: dma.c dma.h flash.c flash.h gpio.c gpio.h pmm.c pmm.h sfr.c sfr.h sys.c sys.h tlv.c tlv.h ucs.c ucs.h wdt_a.c wdt_a.h
  group driverlib/MSP430F5xx_6xx/inc
    ../driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h
  group USB_API/USB_CDC_API
    ../USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group USB_API/USB_Common
    ../USB_API/USB_Common/: defMSP430USB.h device.h usbdma.c types.h usb.c usb.h UsbIsr.h
  group USB_API/USB_HID_API
    ../USB_API/USB_HID_API/: UsbHid.c UsbHid.h UsbHidReq.c UsbHidReq.h
  group USB_API/USB_MSC_API
    ../USB_API/USB_MSC_API/: UsbMsc.h UsbMscReq.c UsbMscReq.h UsbMscScsi.c UsbMscScsi.h UsbMscStateMachine.c UsbMscStateMachine.h
  group USB_API/USB_PHDC_API
    ../USB_API/USB_PHDC_API/: UsbPHDC.c UsbPHDC.h
  group USB_app
    ../USB_app/: keyboard.c keyboard.h mscIntf.c mscIntf.h storageVolume.c storageVolume.h usbEventHandling.c
  group USB_app/FatFs
    ../USB_app/FatFs/: diskio.h ff.c ff.h ffconf.h mmc.c mmc.h
  group USB_config
    ../USB_config/: descriptors.c descriptors.h UsbIsr.c

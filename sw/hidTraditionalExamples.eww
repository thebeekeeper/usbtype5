<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\keyboard_H8_Example\keyboard_H8_Example.ewp</path>
  </project>
  <batchBuild/>
</workspace>


